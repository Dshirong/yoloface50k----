# Keil uVision project atk_f407.uvprojx, settings and files
target CAMERA (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: atk_f407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\..\User;..\..\Drivers;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Middlewares;..\..\Middlewares\X-CUBE-AI\App;..\..\Middlewares\ST\AI\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group User
    ../../User/: main.c stm32f4xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dcmi.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/OV2640/: sccb.c ov2640.c
    ../../Drivers/BSP/TIMER/: btim.c
    ../../Drivers/BSP/DCMI/: dcmi.c
    ../../Drivers/BSP/usart2/: usart2.c
    ../../Drivers/BSP/SRAM/: sram.c
  group Middlewares/USMART
    ../../Middlewares/USMART/: usmart.c usmart_config.c usmart_port.c usmart_str.c
  group Middlewares/X_CUBE_AI
    ../../Middlewares/X-CUBE-AI/App/: app_x-cube-ai.c network.c network_data.c network_data_params.c
    ../../Middlewares/ST/AI/Lib/: NetworkRuntime1020_CM4_Keil.lib
  group Readme
    ../../: readme.txt
